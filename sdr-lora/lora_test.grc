options:
  parameters:
    generate_options: no_gui
    id: lora_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 869.618e6
  states: {}
- name: lora_bw
  id: variable
  parameters:
    value: '62500'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: lora_bw*2
  states: {}
- name: samp_rate_sdr
  id: variable
  parameters:
    value: int(2.4e6)
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    log_level: critical
  states: {}
- name: lora_rx_0
  id: lora_rx
  parameters:
    bw: lora_bw
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '0'
    pay_len: '255'
    print_rx: '[True,True]'
    samp_rate: samp_rate
    sf: '8'
    soft_decoding: 'True'
    sync_word: '[0, 0]'
  states: {}
- name: lora_sdr_crc_verif_0
  id: lora_sdr_crc_verif
  parameters:
    output_crc_check: 'False'
    print_rx_msg: '2'
  states: {state: disabled}
- name: lora_sdr_deinterleaver_0
  id: lora_sdr_deinterleaver
  parameters:
    soft_decoding: 'True'
  states: {state: disabled}
- name: lora_sdr_dewhitening_0
  id: lora_sdr_dewhitening
  parameters: {}
  states: {state: disabled}
- name: lora_sdr_fft_demod_0
  id: lora_sdr_fft_demod
  parameters:
    max_log_approx: 'True'
    soft_decoding: 'True'
  states: {state: disabled}
- name: lora_sdr_frame_sync_0
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: '62500'
    center_freq: int(freq)
    impl_head: 'False'
    os_factor: '4'
    preamb_len: '8'
    sf: '8'
    show_log_port: 'False'
    sync_word: '[0, 0]'
  states: {state: disabled}
- name: lora_sdr_gray_mapping_0
  id: lora_sdr_gray_mapping
  parameters:
    soft_decoding: 'True'
  states: {state: disabled}
- name: lora_sdr_hamming_dec_0
  id: lora_sdr_hamming_dec
  parameters:
    soft_decoding: 'True'
  states: {state: disabled}
- name: lora_sdr_header_decoder_0
  id: lora_sdr_header_decoder
  parameters:
    cr: '8'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '0'
    pay_len: '255'
    print_header: 'True'
  states: {state: disabled}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '2000'
    type: byte
  states: {state: disabled}
- name: network_tcp_sink_1
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '2001'
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '32768'
    int_max: '0'
    int_min: '-100'
    type: complex
    update_time: 32768/samp_rate
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate_sdr // __import__('math').gcd(samp_rate_sdr, samp_rate)
    interp: samp_rate // __import__('math').gcd(samp_rate_sdr, samp_rate)
    type: ccc
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: '"rtl_tcp=10.40.128.8:1234"'
    bb_gain0: '47'
    bw0: samp_rate_sdr
    dc_offset_mode0: '2'
    freq0: freq
    gain0: '47'
    gain_mode0: 'False'
    if_gain0: '47'
    iq_balance_mode0: '2'
    sample_rate: samp_rate_sdr
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [lora_rx_0, '0', network_tcp_sink_1, '0']
- [lora_rx_0, out, blocks_message_debug_0, log]
- [lora_sdr_crc_verif_0, '0', network_tcp_sink_0, '0']
- [lora_sdr_deinterleaver_0, '0', lora_sdr_hamming_dec_0, '0']
- [lora_sdr_dewhitening_0, '0', lora_sdr_crc_verif_0, '0']
- [lora_sdr_fft_demod_0, '0', lora_sdr_gray_mapping_0, '0']
- [lora_sdr_frame_sync_0, '0', lora_sdr_fft_demod_0, '0']
- [lora_sdr_frame_sync_0, '0', qtgui_const_sink_x_0, '0']
- [lora_sdr_gray_mapping_0, '0', lora_sdr_deinterleaver_0, '0']
- [lora_sdr_hamming_dec_0, '0', lora_sdr_header_decoder_0, '0']
- [lora_sdr_header_decoder_0, '0', lora_sdr_dewhitening_0, '0']
- [lora_sdr_header_decoder_0, frame_info, lora_sdr_frame_sync_0, frame_info]
- [rational_resampler_xxx_0, '0', lora_rx_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rtlsdr_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
